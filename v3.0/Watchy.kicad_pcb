# Repository xywatch/watchy-hardware-v3

File README.md:

# watchy-hardware-v3  

<a href="https://github.com/sqfmi/watchy-hardware/tree/v3.0">Watchy Hardware V3</a> has only released schematics and is not fully open-source, nor are there plans to fully open-source it.  

This project is based on the schematic, with the following additions/modifications:  
- Replace the Micro USB port with a Type-C interface
- Added an auto-download serial chip (CH340x)  
- Added some debug interfaces
- Retained the v2.0 RTC chip (PCF8536)  

If you want it to match the official v3.0 exactly, you can omit soldering:  
- The CH340x  
- The PCF8536  
- The 40MHz crystal (the official schematic includes it, but it’s actually not used)

# 中文

<a href="https://github.com/sqfmi/watchy-hardware/tree/v3.0">Watchy Hardware V3</a> 只发布了原理图, 并没有完全开源, 也没有完全开源的计划. 

本项目依据该原理图, 替换了Micro usb为Typec, 增加了自动下载串口CH340x, 增加了调试接口, 保留了2.0 RTC芯片PCF8536.

如想与官方3.0一致, 可不焊接CH340x, PCF8536, 和40M晶振(官方原理图有, 但其实没用到40M晶振)

## KiCad design v3.0/Watchy.kicad_pcb

Parts:
ACC_INT_1: ACC_INT_1; TestPoint_Pad_D0.5mm
ACC_INT_2: ACC_INT_2; TestPoint_Pad_D0.5mm
AE2: SWRA117D
C2, C5, C6, C7, C8, C9, C10: 1uF/50V; C0603-Frame
C3, C4, C12: 4.7uF/50V; C_0805_2012Metric
C11, C14, C23, C25: 100nF; C0402-Frame
C15, C16: 3pF; C_0603_1608Metric; not fitted
C17, C18: 10pF; C0402-Frame
C19, C20: 26pF; C0402-Frame
C21: 10uF; C0402-Frame
C22, C24, C26: 1uF; C0402-Frame
D1, D2, D3, D4: MBR0530; D_SOD-123F
D6: 1N4001; D_SOD-123F
J1: FPC24(0.5MM); 24_Pins_0.5mm_Pitch_ZIF_Connector_UP
J2, J5: Conn_01x06; PinHeader_1x06_P1.27mm_Vertical
J3: Battery; 1.25T-2PWT (Molex 532610271)
L1: 10uH 1A; Inductors_Inductor_Taiyo-Yuden_NR-40xx
L2: 7.5nH; Inductors_Inductor_Taiyo-Yuden_NR-40xx; not fitted
LED1: LED; LED_0402_1005Metric
M1: Vibration_Motor; Motor_Header
Q1: AO3400A; SOT-23
Q4: CJ2301; SOT-23
Q5: S8050; SOT-23
R1, R7, R8, R14, R15: 10K; R0402-Frame
R2, R3: 4.7K; R0402-Frame
R4, R5, R6, R10, R12, R13, R20, R25: 100K; R0402-Frame
R9: 3; R0402-Frame
R11: 680K; R0402-Frame; not fitted
R17, R26: 1K; R0402-Frame
R18: 220K; R0402-Frame; not fitted
R19: 100K; R0402-Frame; not fitted
R21: 1M; R0402-Frame
R22: 10k; R0402-Frame
R24: 51K; R0402-Frame
SW1, SW2, SW3, SW4: BTN; K2-1114SA-A4SW-06
TYPEC1: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
U1: CH340X; MSOP-10_3x3mm_P0.5mm
U2: ME6211C33M5G-N; SOT-23-5
U3: USBLC6-2P6; SOT-666
U4: BMA423; LGA-12_2x2mm_P0.5mm
U5: TP4054; SOT-23-5
U6: PCF8563BS; DFN-10-1EP_3x3mm_P0.5mm_EP1.7x2.5mm
U7: ESP32-S3; QFN-56-1EP_7x7mm_P0.4mm_EP4x4mm
U8: SR2HARU; UDFN-6_L1.6-W1.3-P0.40-TL
Y1: 32.768KHz; Crystal_SMD_3215-2Pin_3.2x1.5mm
Y3: 40MHZ; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3V3: C4.1, C7.1, C12.1, C14.1, C21.1, C22.1, C23.1, C24.1, C25.1, D6.1 (K), J1.15, J1.16, J2.2, J5.2, L1.2, M1.1 (+), R2.1, R3.1, R4.1, R5.1, R6.1, R10.1, R20.1, R22.2, U1.7 (VCC), U1.10 (V3), U2.5 (OUT), U4.3 (VDDIO), U4.7 (VDD), U4.10 (CSB), U7.2 (VDD3P3), U7.3 (VDD3P3), U7.20 (VDD3P3_RTC), U7.46 (VDD3P3_CPU), U7.55 (VDDA), U7.56 (VDDA), U8.6 (VCC)
+BATT: J3.1, Q4.3 (D), R7.1, R11.1, R12.1, U5.3 (VBAT), U6.9 (VDD)
/32K_N: C18.1, U6.2 (OSCO), U7.22 (XTAL_32K_N), Y1.2
/32K_P: C17.1, U6.1 (OSCI), U7.21 (XTAL_32K_P), Y1.1
/40M_N: C20.1, U7.53 (XTAL_N), Y3.3
/40M_P: C19.1, R21.1, Y3.1
ACC_INT_1: ACC_INT_1.1, U4.5 (INT1), U7.18 (GPIO13)
ACC_INT_2: ACC_INT_2.1, U4.6 (INT2), U7.19 (GPIO14)
ADC: R12.2, R13.1, U7.14 (GPIO9)
BTN_1: R4.2, SW1.2, U7.12 (GPIO7)
BTN_2: R5.2, SW2.2, U7.11 (GPIO6), U8.2 (SR1#)
BTN_3: R1.2, R6.2, SW3.2, U1.6 (TNOW/~DTR), U7.5 (GPIO0), U8.5 (SR0#)
BTN_4: R10.2, SW4.2, U7.13 (GPIO8)
BUSY: J1.9, U7.41 (GPIO36)
DC: J1.11, U7.39 (GPIO34)
DN: TYPEC1.A7 (D-), TYPEC1.B7 (D-), U1.2 (UD-), U3.4 (I/O2)
DP: TYPEC1.A6 (D+), TYPEC1.B6 (D+), U1.1 (UD+), U3.6 (I/O1)
EN: C26.1, R22.1, U1.4 (~RTS), U7.4 (CHIP_PU), U8.3 (RST#)
GDR: J1.2, Q1.1 (G), R8.1
GND: AE2.2 (PCB_Trace), C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, D2.1 (K), J1.8, J1.17, J2.1, J3.2, J5.1, Q5.2 (E), R8.2, R9.1, R13.2, R14.2, R15.1, R18.2, R25.2, SW1.1, SW2.1, SW3.1, SW4.1, TYPEC1.A1 (GND), TYPEC1.A12 (GND), TYPEC1.B1 (GND), TYPEC1.B12 (GND), U1.3 (GND), U2.2 (GND), U3.2 (GND), U4.1 (SDO), U4.8 (GNDIO), U4.9 (GND), U5.2 (VSS), U6.5 (VSS), U7.57 (GND), U8.1 (VSS), Y3.4
IO37: J2.3, U7.42 (GPIO37)
IO38: J2.4, U7.43 (GPIO38)
IO39: J2.5, U7.44 (MTCK/GPIO39)
IO40: J2.6, U7.45 (MTDO/GPIO40)
MOSI: J1.14, U7.36 (SPICLK_N/GPIO48)
unnamed: AE2.1 (FEED), C15.1, C16.1, L2.1, L2.2, U7.1 (LNA_IN)
unnamed: C3.1, D1.1 (K), D2.2 (A)
unnamed: C3.2, D3.2 (A), L1.1, Q1.3 (D)
unnamed: D4.1 (K), Q4.2 (S), U2.1 (IN), U2.3 (EN)
unnamed: C14.2, D6.2 (A), M1.2 (-), Q5.3 (C)
unnamed: C2.1, J1.5
unnamed: C6.1, J1.18
unnamed: C8.1, J1.20
unnamed: C9.1, J1.22
unnamed: C10.1, J1.24
unnamed: LED1.2 (A), R26.2
unnamed: Q5.1 (B), R17.1
unnamed: R11.2, R18.1, R19.1
unnamed: R1.1, U1.5 (~CTS)
unnamed: R15.2, U5.5 (PROG)
unnamed: R21.2, U7.54 (XTAL_P)
PREVGH: C5.1, D3.1 (K), J1.21
PREVGL: D1.2 (A), J1.23
RES: J1.10, R20.2, U7.40 (GPIO35)
RESE: J1.3, Q1.2 (S), R9.2
RTC_INT: R7.2, U6.4 (~INT), U7.24 (GPIO18)
RX: J5.6, U1.8 (TXD), U7.50 (U0RXD)
SCK: J1.13, U7.37 (SPICLK_P/GPIO47)
SCL: J5.3, R2.2, U4.12 (SCX), U6.7 (SCL), U7.16 (GPIO11)
SDA: J5.4, R3.2, U4.2 (SDX), U6.6 (SDA), U7.17 (GPIO12)
SS: J1.12, U7.38 (GPIO33)
STAT: LED1.1 (K), U5.1 (STAT), U7.15 (GPIO10)
TX: J5.5, U1.9 (RXD), U7.49 (U0TXD)
USB_D+: U3.1 (I/O1), U7.26 (GPIO20/USB_D+)
USB_D-: U3.3 (I/O2), U7.25 (GPIO19/USB_D-)
USB_DET: R24.2, R25.1, U7.27 (GPIO21)
VBUS: C11.1, D4.2 (A), Q4.1 (G), R14.1, R24.1, R26.1, TYPEC1.A4 (VBUS), TYPEC1.A9 (VBUS), TYPEC1.B4 (VBUS), TYPEC1.B9 (VBUS), U3.5 (VBUS), U5.4 (VDD)
VIB_PWM: R17.2, U7.23 (GPIO17)

Notes on the sheet:
The current pin allocation for the BMA423 has pin 10 left floating but it should be connected to +3.3 to avoid the potential of the device switching to SPI interface. This is according to the datasheet from Bosch.
Real Time Clock
ESP32-S3
Vibration Motor
1M电阻可以不用, 或可以用小点的
如果使用ESP RTC就不要焊PCF8563BS
ESP32-S3 可以外接 32.768kHz 晶振， 但仅在需要 高精度 RTC 或低功耗优化 时必要。 外部晶振可提高唤醒定时精度，减少功耗（内部 RC 振荡器在睡眠时漂移较大) 如果已使用 PCF8563BS，ESP32-S3 可不接晶振， 简化设计。
C21-C26全用104(100nF)
DP（Data Positive）, DN（Data Negative）
E-Paper Driver
P输入, N输出
Power & Battery
USB
BTN3,BTN2同时按低电平,EN为低电平
CH340X
usb静电防护芯片
对于ESP32-S3的40MHz晶振，12~15pF 是常见安全值
5v--51k电阻--电压测试点--100k电阻-- 电压测试点 = 5v * 100/(100+51) = 3.31v 5v--2k电阻--电压测试点--3k电阻-- 电压测试点 = 5v * 3/(5) = 3v
Buttons
Accelerometer
I2C 上拉电阻（4.7kΩ~10kΩ）

Board: 2 copper layers, 33.8 x 46.0 mm, 76 parts (0 on the bottom side), 57 nets.

File v3.0/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
ACC_INT_1,TestPoint_Pad_D0.5mm,1,ACC_INT_1,
ACC_INT_2,TestPoint_Pad_D0.5mm,1,ACC_INT_2,
AE2,SWRA117D,1,SWRA117D,
"C10, C2, C5, C6, C7, C8, C9",C0603-Frame,7,1uF/50V,
"C11, C14, C23, C25",C0402-Frame,4,100nF,
"C12, C3, C4",0805,3,4.7uF/50V,
"C17, C18",C0402-Frame,2,10pF,
"C19, C20",C0402-Frame,2,26pF,
C21,C0402-Frame,1,10uF,
"C22, C24, C26",C0402-Frame,3,1uF,
"D1, D2, D3, D4",D_SOD-123F,4,MBR0530,
D6,D_SOD-123F,1,1N4001,
J1,24_Pins_0.5mm_Pitch_ZIF_Connector_UP,1,FPC24(0.5MM),
"J2, J5",PinHeader_1x06_P1.27mm_Vertical,2,Conn_01x06,
J3,1.25T-2PWT (Molex 532610271),1,Battery,
L1,Inductors_Inductor_Taiyo-Yuden_NR-40xx,1,10uH 1A,
LED1,0402,1,LED,
M1,Motor_Header,1,Vibration_Motor,
Q1,SOT-23,1,AO3400A,
Q4,SOT-23,1,CJ2301,
Q5,SOT-23,1,S8050,
"R1, R14, R15, R22, R7, R8",R0402-Frame,6,10K,
"R10, R12, R13, R16, R20, R25, R4, R5, R6",R0402-Frame,9,100K,
"R17, R26",R0402-Frame,2,1K,
"R2, R3",R0402-Frame,2,4.7K,
R21,R0402-Frame,1,1M,
"R23, R24",R0402-Frame,2,51K,
R9,R0402-Frame,1,3,
"SW1, SW2, SW3, SW4",K2-1114SA-A4SW-06,4,BTN,
TYPEC1,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,USB_C_Receptacle_USB2.0_14P,
U1,MSOP-10_3x3mm_P0.5mm,1,CH340X,
U2,SOT-23-5,1,ME6211C33M5G-N,
U3,SOT-666,1,USBLC6-2P6,
U4,LGA-12_2x2mm_P0.5mm,1,BMA423,
U5,SOT-23-5,1,TP4054,
U6,DFN-10-1EP_3x3mm_P0.5mm_EP1.7x2.5mm,1,PCF8563BS,
U7,QFN-56-1EP_7x7mm_P0.4mm_EP4x4mm,1,ESP32-S3,
U8,UDFN-6_L1.6-W1.3-P0.40-TL,1,SR2HARU,
Y1,Crystal_SMD_3215-2Pin_3.2x1.5mm,1,32.768KHz,
Y3,Crystal_SMD_2016-4Pin_2.0x1.6mm,1,40MHZ,

## Commit log

2025-04-10 init
2025-04-19 change ch340x position
2025-04-20 update b.silk position
2025-04-23 font
